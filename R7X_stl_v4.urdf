Commit message: Fix Docker issues: PyKDL installation, NumPy version, and URDF parsing

File: R7X_stl_v4.urdf (robot description, URDF)
Before this commit: robot Robot, 8 links, 7 joints
Joints:
- joint endeffector_jnt: axis 100 -> 1.00000000 0.00000000 0.00000000
